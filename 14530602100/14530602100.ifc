Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-07T08:17:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 07 08:17:07 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{6B718714-E46D-427D-B47F-9DBF1FB319C0}\ifc * Database version: 5507 * Database creation date: Tue Nov 07 08:17:07 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 07 08:17:07 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 07 08:17:07 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: 8mm Head
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDoor: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm, 14530602100:dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm:194117
In: Level 1
Type - ParameterTakesPrecedence: no; Sizeable: no
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Data - AdjustableStrength: 2-4; ClassificationGradesMinimumCategoryOfUse: EN 1154 - 4: For closing doors from 180 degrees; ClassificationGradesMinimumCorrosionResistance: EN 1154 - 3: High resistance; ClassificationGradesMinimumDoorMass: EN 1154 - 3: 60 kg mass doors; ClassificationGradesMinimumDurability: EN 1154 - 8: Tested to 500 000 cycles; ClassificationGradesMinimumFireResistance: EN 1154 - 1: Suitable for fire smoke resistant door assemblies; ClassificationGradesMinimumSafety: EN 1154 - 1: Safe to use
Type - Dimensions - DoorCloserHeight: 62 mm; DoorCloserLength: 220 mm; DoorCloserThickness: 39 mm; DoorLeafThickness: 40 mm
Type - General - Author: Gytautas Balevičius; BIMObjectName: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; DesignCountry: Denmark; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 08 71 00; MasterFormat2014Description: Door hardware; NBSCertification: n/a; NBSDescription: Controlled door closers; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-60/305; NBSTypeID: n/a; OmniclassCode: 23-17 19 11 19 11; OmniclassDescription: Door Closers; ProductFamily: Hardware; ProductGroup: Door closers; ProductInformation: http://dline.com/product/knud-holscher-collection-door-closer-cam-actionsurface-mounted/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=with-track-arm-snp-ss316cover#; ProductionCountry: Lithuania; ProductSKU: 14530602100; Revision: n/a; Uniclass2015Code: Pr_30_36_59_15; Uniclass2015Title: Controlled door closers; Uniclass2015Version: Products v1.5; UNSPSCCode: 30171514; Version: 1; Weight Net (kg): 0
Type - Identity Data - Description: Door closer, EN 2-4; with a track arm and AISI 316 cover; Manufacturer: info@dline.com; Type Mark: 22; Type Name: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm
Type - Materials and Finishes - MainMaterial: AISI 316
Type - Other - AccessibilityPerformance: n/a; AssetType: fixed; Category: Pr_30_36_59_15:Controlled door closers; CodePerformance: EN 1154; Color: Steel; Constituents: 1x - Door closer body; 1x - Stainless steel cover; 1x - Track arm; 1x - Channel;; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14530602100; Features: n/a; Finish: Satin; Grade: n/a; Material: AISI 316 stainless steel; ModelNumber: n/a; ModelReference: 45-25-60/305; Name: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; ReplacementCost: n/a; Shape: n/a; Size: 62 x 39 x 259 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
OverallHeight: 79 mm; OverallWidth: 523 mm
Pset_DoorCommon - Reference: n/a; IsExternal: no; FireRating: EN 1154 - 1: Suitable for use on fire/smoke door assemblies (tested with 200,000 test cycles on a test door); AcousticRating: n/a; SecurityRating: n/a; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; GlazingAreaFraction: 0
Pset_ManufacturerTypeInformation - ModelReference: 45-25-60/305; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1
Dimensions - Area: 0.055437 m2; Volume: 0.000846683 m3
Identity Data - Mark: 1
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Doors; Family: 14530602100: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; Family and Type: 14530602100: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14530602100: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; Type Id: 14530602100: dline_Hardware_DoorCloser_CamAction_EN2-4_TrackArm; WarrantyStartDate: 1900-12-31T23:59:59
Phasing - Phase Created: New Construction
